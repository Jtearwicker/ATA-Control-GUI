options:
  parameters:
    author: Yiwei Chai
    generate_options: qt_gui
    id: ts_usrpsource_plswork
    output_language: python
    title: SETI Data Pipeline (Test)
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '8493.75'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '35'
  states: {}
- name: f_start
  id: variable
  parameters:
    comment: MHz
    value: center_freq - ((bandwidth)/(2e6))
  states: {}
- name: f_start_0
  id: variable
  parameters:
    comment: MHz
    value: '-0.4'
  states: {}
- name: f_stop
  id: variable
  parameters:
    comment: MHz
    value: center_freq +(int(bandwidth)/(2e6))
  states: {}
- name: f_stop_0
  id: variable
  parameters:
    comment: MHz
    value: '0.4'
  states: {}
- name: n_coarse_chan
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_fine_chans
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: n_fine_chans/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: ant_list
  id: parameter
  parameters:
    comment: |-
      can acquire data via USRP:
      1a, 1c, 1f, 2a, 2b, 2h, 3c, 1k, 4g, 5c

      all ant:
      1a, 1b, 1c, 1d, 1e, 1f, 1g, 1h, 1j, 1k
      2a, 2b, 2c, 2d, 2e, 2f, 2g, 2h, 2j, 2k, 2l, 2m
      3c, 3d, 3e, 3f, 3g, 3h, 3j, 3l
      4e, 4f, 4g, 4h, 4j, 4k, 4l
      5b, 5c, 5e, 5g, 5h
    label: antennae list
    type: str
    value: 1a, 1c, 1f, 2a, 2b, 2h, 3c, 1k, 4g, 5c
  states: {state: disabled}
- name: az
  id: parameter
  parameters:
    comment: dec deg
    label: az
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_2_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: n_fine_chans
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(n_fine_chans)
    type: complex
  states: {}
- name: dec
  id: parameter
  parameters:
    comment: dec deg
    label: dec
    type: eng_float
    value: '5.225785'
  states: {}
- name: el
  id: parameter
  parameters:
    comment: dec deg
    label: el
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: f_start
  id: parameter
  parameters:
    label: start freq
    type: intx
    value: int(center_freq - ((bandwidth)/(2*1000000)))
  states: {state: disabled}
- name: f_stop
  id: parameter
  parameters:
    label: stop freq
    type: intx
    value: int(center_freq -(int(bandwidth)/(2e6)))
  states: {state: disabled}
- name: fcntr
  id: parameter
  parameters:
    label: centre frequency
    type: eng_float
    value: 545e6
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: n_fine_chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(n_fine_chans)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '291360'
    decim: decimation
    samp_rate: '2929690'
    taps: firdes.low_pass(1, samp_rate/decimation, 700, 50)
    type: ccc
  states: {}
- name: n_ints_in_file
  id: parameter
  parameters:
    label: '# integrations'
    type: intx
    value: '60'
  states: {}
- name: pfb_channelizer_ccf_0_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '72'
    ch_map: '[]'
    nchans: n_coarse_chan
    osr: '1.0'
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: bandwidth*1e6
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: ra
  id: parameter
  parameters:
    comment: dec hrs
    label: RA
    type: eng_float
    value: '7.456805'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: source name
    type: str
    value: fake_luyten
  states: {}
- name: tsamp
  id: parameter
  parameters:
    label: time step in secs
    type: eng_float
    value: '1'
  states: {}
- name: tstart
  id: parameter
  parameters:
    label: obs start time
    type: eng_float
    value: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=10.11.1.20,addr1=10.11.1.22"'
    dev_args: '""'
    gain0: '0'
    num_mboards: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*.5555
    timeout: '100'
    type: float
    vlen: n_fine_chans
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_2_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_1_0, '0']
- [fft_vxx_1_0, '0', blocks_complex_to_mag_squared_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', pfb_channelizer_ccf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_channelizer_ccf_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
